PACKAGECONFIG_append = " kwd"

