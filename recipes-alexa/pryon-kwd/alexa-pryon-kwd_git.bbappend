AMAZON_ALEXA_PRYON_KWD_PLATFORM = "rpi3"
