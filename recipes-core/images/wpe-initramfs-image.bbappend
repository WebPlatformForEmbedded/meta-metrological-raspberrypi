IMAGE_FSTYPES_rpi = " ${INITRAMFS_FSTYPES}"
