PLUGIN_SPLASH_IMAGE_FORMAT = "PNG"
PLUGIN_ENABLE_AUDIO_DOWNMIX = "true"
