PACKAGECONFIG_append = " messenger packager"

# Raspberry PI 3 has 4 cores, set to 4 for RPIs
WPE_WEBKITBROWSER_THREADEDPAINTING = "2"
