WPEFRAMEWORK_PLATFORM_VIDEO_SUBSYSTEM = "vchiq"

